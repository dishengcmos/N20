# Keil uVision project n10.uvprojx, settings and files
target n03 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: n10 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\mcu\common;..\source;..\driver\inc;..\midware;..\hardware;..\detector
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c sysconfig.c rtcconfig.c main.h
  group driver
    ../driver/src/: ddl.c sysctrl.c spi.c gpio.c flash.c rtc.c adc.c bgr.c timer3.c
  group hardware
    ../hardware/: lcd_api.c key.c
  group detector
    ../detector/: displaydriver.c cachevalue.c chart.c wire.c dishelp.c
  group midware
    ../midware/: spi_mid.c gpio_mid.c adc_mid.c flash_mid.c pwm_mid.c
software components: CMSIS:CORE 5.4.0
